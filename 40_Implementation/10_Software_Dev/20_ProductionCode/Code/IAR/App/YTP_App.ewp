# IAR project YTP_App.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\Application\Bsw\Mcals\Libraries\CMSIS\inc; ..\..\Application\Bsw\Mcals\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Application\Bsw\Services\Rtos\inc; ..\..\Application\Bsw\Startup\inc; ..\..\Application\Asw\Key\inc; ..\..\Application\Asw\Led\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Application\Bsw\Services\Rtos\inc
  OBJCOPY.OOCOutputFile: YTP_App.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Link\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Asw/Key/src
    ../../Application/Asw/Key/src/: key.c
  group Asw/Led/src
    ../../Application/Asw/Led/src/: led.c
  group Bsw/Mcals/Libraries/CMSIS/src
    ../../Application/Bsw/Mcals/Libraries/CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Bsw/Mcals/Libraries/STM32F10x_StdPeriph_Driver/src
    ../../Application/Bsw/Mcals/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bsw/Services/Rtos/src
    ../../Application/Bsw/Services/Rtos/src/: croutine.c event_groups.c heap_4.c list.c port.c portasm.s queue.c tasks.c timers.c
  group Bsw/Startup/src
    ../../Application/Bsw/Startup/src/: delay.c main.c startup_stm32f10x_hd.s stm32f10x_it.c sys.c
