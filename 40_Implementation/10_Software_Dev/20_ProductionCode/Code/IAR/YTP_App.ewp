# IAR project YTP_App.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Application\Bsw\Mcals\Libraries\CMSIS\inc; ..\Application\Bsw\Mcals\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Application\Bsw\Services\Rtos\inc; ..\Application\Bsw\Startup\inc; ..\Application\Asw\Key\inc; ..\Application\Asw\Led\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Application\Bsw\Services\Rtos\inc
  OBJCOPY.OOCOutputFile: YTP_App.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\Application\Bsw\Startup\src\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Asw/Key/src
    ../Application/Asw/Key/src/: key.c
  group Asw/Led/src
    ../Application/Asw/Led/src/: led.c
  group Bsw/Mcals/Libraries/CMSIS/src
    ../Application/Bsw/Mcals/Libraries/CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Bsw/Mcals/Libraries/STM32F10x_StdPeriph_Driver/src
    ../Application/Bsw/Mcals/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bsw/Services/Rtos/src
    ../Application/Bsw/Services/Rtos/src/: heap_2.c list.c port.c portasm.s portmacro.h queue.c tasks.c
  group Bsw/Startup/src
    ../Application/Bsw/Startup/src/: main.c system.c
